# IAR project main.ewp, settings and files
configuration OUTPUT (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x900
  General.SCRStackSize: 64
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-0t-ec_nomul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: tiny13 ATtiny13
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.newCCIncludePaths: Main\; Application\; Module\; Driver\
  ICCAVR.IccLang: 1
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnktiny13t.xcl
  group Application
    Application/: Power.c
  group Driver
    Driver/: adc.c gpio.c sleep.c wdt.c
  group Main
    Main/: main.c
  group ReadMe
    ReadMe/: Core.txt
